# IAR project .ewp.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG1P233F256GM48 SiliconLaboratories EFR32MG1P233F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$; autogen
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: $FILE_DIR$; autogen
  OBJCOPY.OOCOutputFile: .ewp.s37
  ILINK.IlinkOutputFile: .ewp.out
  group (top)
    ./: .ewp.ipcf
